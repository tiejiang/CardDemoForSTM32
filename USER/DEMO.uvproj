# Keil uVision project DEMO.uvproj, settings and files
target DEMO (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CMSIS;..\STM32F10x_StdPeriph_Driver\inc;..\USER;..\MyLib
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLib
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_exti.c
  group USER
    ./: stm32f10x_it.c stm32f10x_conf.h main.c
  group MyLib
    ../MyLib/: Delay.c Moto.c LED.c NVIC.c usart1.c CarControl.c NEW_PWM_TEST.c
